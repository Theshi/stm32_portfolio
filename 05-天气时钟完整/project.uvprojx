# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Library;.\System;.\FreeRTOS\portable;.\FreeRTOS\src;.\BSP;.\LVGL;.\LVGL\port;.\LVGL\src;.\UI;.\UI\IMG;.\Service;.\Driver\ESP8266;.\Driver\ILI9341;.\Driver\XPT2046;.\Driver\W25Q64;.\UI\Font_SCh_16;.\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h list.c list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group FreeRTOS/portable
    ./FreeRTOS/portable/: heap_4.c port.c portmacro.h
  group LVGL
    ./LVGL/: lv_conf.h lvgl.h
    ./LVGL/port/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.c lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
    ./LVGL/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h
    ./LVGL/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ./LVGL/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
    ./LVGL/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
    ./LVGL/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
    ./LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
    ./LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
    ./LVGL/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw.c lv_draw_sw.h
    ./LVGL/src/extra/layouts/: lv_layouts.h
    ./LVGL/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ./LVGL/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ./LVGL/src/extra/libs/: lv_libs.h
    ./LVGL/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
    ./LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
    ./LVGL/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
    ./LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ./LVGL/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
    ./LVGL/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
    ./LVGL/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h
    ./LVGL/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
    ./LVGL/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
    ./LVGL/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ./LVGL/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
    ./LVGL/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ./LVGL/src/extra/themes/: lv_themes.h
    ./LVGL/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ./LVGL/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ./LVGL/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ./LVGL/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ./LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ./LVGL/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ./LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ./LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ./LVGL/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ./LVGL/src/extra/widgets/led/: lv_led.c lv_led.h
    ./LVGL/src/extra/widgets/list/: lv_list.c lv_list.h
    ./LVGL/src/extra/widgets/menu/: lv_menu.c lv_menu.h
    ./LVGL/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ./LVGL/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ./LVGL/src/extra/widgets/span/: lv_span.c lv_span.h
    ./LVGL/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ./LVGL/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ./LVGL/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ./LVGL/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ./LVGL/src/extra/widgets/win/: lv_win.c lv_win.h
    ./LVGL/src/extra/widgets/: lv_widgets.h
    ./LVGL/src/extra/: lv_extra.c lv_extra.h
    ./LVGL/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ./LVGL/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
    ./LVGL/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
    ./LVGL/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group System
    ./System/: Delay.c Delay.h MyRTC.c MyRTC.h SysTick.c SysTick.h
  group BSP
    ./BSP/: bsp_spi.c bsp_spi.h bsp_usart.c bsp_usart.h core_delay.c core_delay.h
  group Driver
    ./Driver/W25Q64/: W25Q64.c W25Q64.h
    ./Driver/ESP8266/: bsp_esp8266.c bsp_esp8266.h
    ./Driver/ILI9341/: bsp_ili9341_lcd.c bsp_ili9341_lcd.h
    ./Driver/XPT2046/: bsp_xpt2046_lcd.c bsp_xpt2046_lcd.h
  group User
    ./User/: FreeRTOSConfig.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group UI
    ./UI/: UI_API.h UI_Task.c UI_Main.c UI_Boot.c UI_Wifi.c
    ./UI/IMG/: LVG_Logo.c TEMP_Logo.c WIFI_Logo.c GitHub.c
    ./UI/Font_SCh_16/: my_font_SCH_16.c
  group Service
    ./Service/: common.c common.h http_client.c http_client.h http_utils.c http_utils.h
  group Task
    ./Task/: task_boot.c task_boot.h task_http.c task_http.h task_startup.c task_startup.h
